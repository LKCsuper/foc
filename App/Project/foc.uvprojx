# Keil uVision project foc.uvprojx, settings and files
target Foc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: foc +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__CC_ARM,__TARGET_FPU_VFP=1,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,SIMULINK_USE_ARM_MATH
  c misc: --locale=english
  c include: ..\..\Library\STM32F4xx_StdPeriph_Driver\inc;..\User;..\..\Library\Bsp\inc;..\..\Library\Hal\inc;..\motor\inc;..\..\Library\Common\inc;..\cmd\inc;..\..\ThirtyLibrary\ymodem\inc;..\..\ThirtyLibrary\FreeRTOS\include;..\..\ThirtyLibrary\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\ThirtyLibrary\XCmd\inc;..\..\ThirtyLibrary\FreeRTOS\CMSIS_RTOS_V2;..\..\ThirtyLibrary\FreeRTOS\FreeRTOS-Plus-CLI;..\..\ThirtyLibrary\nr_micro_shell-master\inc;..\Configs\inc;..\..\ThirtyLibrary\letter-shell-master\inc;..\..\ThirtyLibrary\letter-shell-master\port;..\..\ThirtyLibrary\FlashDB\inc;..\..\ThirtyLibrary\Fal\inc;..\..\Doc\matlab\foc_simulink0_ert_rtw;..\Motor_Simple_Foc\inc;..\Motor_Param\inc;..\RTT;..\Motor_Param\inc;..\..\ThirtyLibrary\easyflash\inc;..\Motor_Sensor\inc;..\..\Library\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group CMSIS
    ../User/: system_stm32f4xx.c
    ../../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group Library
    ../../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Bsp
    ../../Library/Bsp/: bsp_usart.c bsp_misc.c bsp_tim.c bsp_adc.c bsp_dma.c bsp.c bsp_gpio.c bsp_it.c
  group Hal
    ../../Library/Hal/port/stm32f4/: hal_motor_stm32f4.c
  group Cmd
    ../cmd/: command.c cmd_task.c cmd_serial_plot.c cmd_openloop.c cmd_misc.c cmd_show_param.c cmd_encoder.c
    ../Cmd/: cmd_duty.c cmd_detect.c
  group Ymodem
    ../../ThirtyLibrary/ymodem/: ymodem.c ymodem_common.c ymodem_config.c
  group Freertos
    ../../ThirtyLibrary/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../ThirtyLibrary/FreeRTOS/portable/MemMang/: heap_4.c
    ../../ThirtyLibrary/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Configs/: freertos.c freertos_port.c
  group Cmsis_OS2
    ../../ThirtyLibrary/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group Common
    ../../Library/Common/: common.c
  group FlashDB
    ../../ThirtyLibrary/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group Fal
    ../../ThirtyLibrary/Fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../../ThirtyLibrary/Fal/port/: fal_flash_stm32f4.c
  group Rtt
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_DEBUG.c
  group Motor_Param
    ../motor_param/: motor_param.c
  group Easyflash
    ../../ThirtyLibrary/easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ../../ThirtyLibrary/easyflash/port/: ef_port.c
  group Motor
    ../motor/: motor_foc.c motor_it.c motor_sense.c motor_hfi_start.c motor_alignment.c motor_if_start.c motor_pid.c motor_protect.c motor_speed.c motor_sensorless.c motor_task.c motor_utils.c motor_ctrl.c motor.c
    ../Motor/: motor_math.c
    ../cmd/: cmd_env.c
  group Motor_Simple
    ../motor_simple_foc/: motor_simple_bldc.c motor_simple_foc.c motor_simple_utils.c
  group Motor_Detect
    ../motor_param/: motor_detect.c flash_storage.c
  group Motor_Sensor
    ../motor_sensor/: motor_hall.c motor_encoder.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.16.2
